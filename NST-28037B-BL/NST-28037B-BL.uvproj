# Keil uVision project NST-28037B-BL.uvproj, settings and files
target NST-28037B-BL (ARM-ADS)
  device: STM32F100C4 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: NST-28037B-BL
  c flags: Optim=1 OneElfS=1
  c define: NDEBUG USE_STDPERIPH_DRIVER STM32F10X_LD_VL STM32F10XX4
  c include: .\src;..\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\CoreSupport;..\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x800
  memory RVCT9: RAM 0x20000000 size 0x1000
  group App
    ./src/: main.c startup_stm32f10x_ld_vl.s stm32f10x_conf.h
  group STM32_Lib
    ../STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_flash.c
